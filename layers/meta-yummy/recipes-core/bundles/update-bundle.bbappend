RAUC_BUNDLE_VERSION = "v1.0"
RAUC_BUNDLE_DESCRIPTION = "The great yumy update"
RAUC_BUNDLE_FORMAT = "verity"
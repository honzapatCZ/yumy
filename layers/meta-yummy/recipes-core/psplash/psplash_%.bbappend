FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SPLASH_IMAGES = "file://splash-yumy.png;outsuffix=default"

SRC_URI += "file://psplash-colors.h;subdir=git"